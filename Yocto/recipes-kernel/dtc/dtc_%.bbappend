BUILD_CFLAGS:append = " -Wno-error=discarded-qualifiers -Wno-error"
CFLAGS:append = " -Wno-error=discarded-qualifiers -Wno-error"
